# Keil uVision project Lab7 ADC code.uvprojx, settings and files
target Target 1 (6180000::V6.18::.\ARMCLANG)
  device: STM32F429ZITx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IROM(0x08000000,0x200000) IRAM(0x20000000,0x30000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Lab7 ADC code
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Source Group 1
    ./: ADC.c DAC.c main.c lcd.c Timer.c Buttons.c Buzzer.c LED.c usart.c
software components: CMSIS:CORE 6.1.0, Device:Startup 2.6.3
